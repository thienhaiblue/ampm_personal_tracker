# Keil uVision project project_bootloader.uvproj, settings and files
target KL25Z128 - Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: GT1022_BOOT
  AfterMake: fromelf --bin --output .\Flash\GT1022_BOOT.bin .\Flash\GT1022_BOOT.axf
  c flags: Optim=1
  c define: KEIL FREEDOM CMSIS USB __NOT_USE_HID_RESPORT_FUNC__
  c include: ..\..\..\src\projects\project_bootloader;..\..\..\src\common;..\..\..\src\cpu;..\..\..\src\cpu\headers\CMSIS\MKL25Z4\Include;..\..\..\src\drivers\llwu;..\..\..\src\drivers\lptmr;..\..\..\src\drivers\mcg;..\..\..\src\drivers\pmc;..\..\..\src\drivers\rcm;..\..\..\src\drivers\rtc;..\..\..\src\drivers\smc;..\..\..\src\drivers\uart;..\..\..\src\drivers\cmp;..\..\..\src\platforms;..\..;..\..\..\src\cpu\headers\CMSIS;..\..\..\src\drivers\flash;..\..\..\src\drivers\usb;..\..\..\src\Libraries\common_lib\flash_mem;..\..\..\src\drivers\spi;..\..\..\src\Libraries\common_lib\ringbuff;..\..\..\src\drivers\FTFA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group project
    ../../../src/projects/project_bootloader/: FlashProg.c project_bootloader.c
  group cpu
    ../../../src/cpu/: system_MKL25Z4.c arm_cm0.c
    ../../../src/projects/project_bootloader/: sysinit.c startup_MKL25Z4.s
  group drivers
    ../../../src/drivers/spi/: spi.c
    ../../../src/drivers/flash/: fmc.c
    ../../../src/Libraries/common_lib/ringbuff/: ringbuf.c
    ../../../src/drivers/FTFA/: flash_FTFA.c flash_ramFunc.c
  group platforms
    ../../../src/platforms/: tower.h
    ../../../src/cpu/headers/: MKL25Z4.h MemMapPtr_KL25Z4.h
  group usb
    ../../../src/drivers/usb/: hiduser.c usbcore.c usbhw.c
    ../../../src/projects/project_bootloader/: usbdesc.c usbuser.c mscuser.c cdcuser.c
  group flash_mem
    ../../../src/Libraries/common_lib/flash_mem/: sst25.c
