# Keil uVision project project_main.uvproj, settings and files
target KL25Z128 - Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: GT1022
  AfterMake: fromelf --bin ".\FLash\GT1022.axf" --output ".\FLash\GT1022.bin"
  c flags: Optim=1
  c define: KEIL FREEDOM CMSIS USB
  c include: ..\..\..\src\projects\project_main;..\..\..\src\common;..\..\..\src\cpu;..\..\..\src\cpu\headers\CMSIS\MKL25Z4\Include;..\..\..\src\drivers\llwu;..\..\..\src\drivers\lptmr;..\..\..\src\drivers\mcg;..\..\..\src\drivers\pmc;..\..\..\src\drivers\rcm;..\..\..\src\drivers\rtc;..\..\..\src\drivers\smc;..\..\..\src\drivers\uart;..\..\..\src\drivers\cmp;..\..\..\src\drivers\tick;..\..\..\src\platforms;..\..;..\..\..\src\cpu\headers\CMSIS;..\..\..\src\Libraries\common_lib\acclerometer;..\..\..\src\Libraries\common_lib\flash_mem;..\..\..\src\Libraries\common_lib\gps;..\..\..\src\Libraries\common_lib\gsm_modem;..\..\..\src\Libraries\common_lib\ringbuff;..\..\..\src\Libraries\common_lib\string_parser;..\..\..\src\Libraries\common_lib\sys_time;..\..\..\src\Libraries\common_lib\usb;..\..\..\src\drivers\flash;..\..\..\src\drivers\spi;..\..\..\src\drivers\usb;..\..\..\src\drivers\bsp;..\..\..\src\drivers\i2c;..\..\..\src\FATFS\ff9b\src;..\..\..\src\FATFS\ff9b\src\option;..\..\..\src\drivers\i2c;..\..\..\src\Libraries\common_lib\acclerometer;..\..\..\src\Libraries\common_lib\angle_calculation;..\..\..\src\drivers\FTFA;..\..\..\src\Libraries\common_lib\pedometer
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group project
    ../../../src/projects/project_main/: project_main.c project_common.c app.c power_management.c gsm_gprs_tasks.c sos_tasks.c io_tasks.c upload_config_task.c gps_task.c
  group cpu
    ../../../src/cpu/: start.c sysinit.c system_MKL25Z4.c arm_cm0.c nmi_isr_handler.c startup_MKL25Z4.s
  group drivers
    ../../../src/drivers/llwu/: llwu.c
    ../../../src/drivers/mcg/: mcg.c
    ../../../src/drivers/rcm/: rcm.c
    ../../../src/drivers/smc/: smc.c
    ../../../src/drivers/uart/: uart.c
    ../../../src/drivers/flash/: fmc.c
    ../../../src/drivers/spi/: spi.c
    ../../../src/drivers/i2c/: hal_i2c.c
    ../../../src/drivers/FTFA/: flash_FTFA.c flash_ramFunc.c
  group platforms
    ../../../src/platforms/: tower.h
    ../../../src/cpu/headers/: MKL25Z4.h MemMapPtr_KL25Z4.h
  group usb
    ../../../src/drivers/usb/: usbcore.c usbhw.c
    ../../../src/projects/project_main/: usbdesc.c usbuser.c
  group ringBuf
    ../../../src/Libraries/common_lib/ringbuff/: ringbuf.c
  group HID
    ../../../src/drivers/usb/: hiduser.c
  group flash_mem
    ../../../src/Libraries/common_lib/flash_mem/: sst25.c
  group modem
    ../../../src/Libraries/common_lib/gsm_modem/: modem.c
    ../../../src/projects/project_main/: at_command_parser.c
  group sys_cfg
    ../../../src/projects/project_main/: system_config.c
  group time
    ../../../src/Libraries/common_lib/sys_time/: m_time.c sys_time.c
  group string_parser
    ../../../src/Libraries/common_lib/string_parser/: string_parser.c
  group database
    ../../../src/projects/project_main/: db.c
  group tracker
    ../../../src/projects/project_main/: tracker.c gprs_cmd_ctrl.c
  group gps
    ../../../src/Libraries/common_lib/gps/: gps.c
  group tick
    ../../../src/drivers/tick/: tick.c
  group debug_config_app
    ../../../src/projects/project_main/: dbg_cfg_app.c
  group FATFS
    ../../../src/FATFS/ff9b/src/: diskio.c ff.c flash_mem.c
  group audio
    ../../../src/projects/project_main/: audio.c
  group DTMF
    ../../../src/projects/project_main/: DTMF_app.c DTMF.c
  group acclerometer
    ../../../src/Libraries/common_lib/acclerometer/: xl362_io.c
  group pedometer
    ../../../src/Libraries/common_lib/pedometer/: ambo_pedometer.c pedometer_task.c
